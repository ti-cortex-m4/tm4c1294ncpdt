# IAR project enet_s2e.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..\..; ..\..\..\..\third_party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\third_party\FreeRTOS; ..\..\..\..\third_party\lwip-1.4.1\apps; ..\..\..\..\third_party\FreeRTOS\Source\include; ..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include; ..\..\..\..\third_party\lwip-1.4.1\src\include; ..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4; ..\..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: enet_s2e.bin
  ILINK.IlinkOutputFile: enet_s2e.out
  ILINK.IlinkIcfFile: enet_s2e.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ./: config.c enet_fs.c enet_s2e.c idle_task.c lwip_task.c serial.c serial_task.c startup_ewarm.c telnet.c
    ../../../../third_party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../utils/: eeprom_pb.c locator.c lwiplib.c ringbuf.c uartstdio.c ustdlib.c
    ../../../../third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../third_party/lwip-1.4.1/apps/httpserver_raw/: httpd.c
    ../drivers/: pinout.c
    ../../../../third_party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.S
