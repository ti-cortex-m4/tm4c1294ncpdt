# Keil uVision project enet_s2e.uvproj, settings and files
target enet_s2e (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: enet_s2e
  AfterMake: fromelf --bin --output .\rvmdk\enet_s2e.bin .\rvmdk\enet_s2e.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA1
  c misc: --c99
  c include: .;..;..\..\..\..;..\..\..\..\third_party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\third_party\FreeRTOS;..\..\..\..\third_party\lwip-1.4.1\apps;..\..\..\..\third_party\FreeRTOS\Source\include;..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include;..\..\..\..\third_party\lwip-1.4.1\src\include;..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4;..\..\..\..\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: enet_s2e.sct
  link misc: --entry Reset_Handler
  group Source
    ./: config.c enet_fs.c enet_s2e.c idle_task.c lwip_task.c serial.c serial_task.c startup_rvmdk.S telnet.c
    ../../../../third_party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../utils/: eeprom_pb.c locator.c lwiplib.c ringbuf.c uartstdio.c ustdlib.c
    ../../../../third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../third_party/lwip-1.4.1/apps/httpserver_raw/: httpd.c
    ../drivers/: pinout.c
    ../../../../third_party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
