# IAR project ser2enet.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx4xx TexasInstruments LM3Sx4xx
  ICCARM.CCDefines: ewarm; PART_LM3S6432
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..; ..\..\..\third_party\lwip-1.3.2\apps; ..\..\..\third_party\lwip-1.3.2\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.2\src\include; ..\..\..\third_party\lwip-1.3.2\src\include\ipv4
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ser2enet.bin
  ILINK.IlinkOutputFile: ser2enet.out
  ILINK.IlinkIcfFile: ser2enet.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
  group Source
    ./: config.c fs_s2e.c ser2enet.c serial.c startup_ewarm.c telnet.c upnp.c
    ../../../utils/: flash_pb.c locator.c lwiplib.c ringbuf.c swupdate.c uartstdio.c ustdlib.c
    ../../../third_party/lwip-1.3.2/apps/httpserver_raw/: httpd.c
